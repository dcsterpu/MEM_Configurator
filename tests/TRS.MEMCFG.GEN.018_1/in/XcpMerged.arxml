<?xml version="1.0" encoding="UTF-8"?>
<!-- ARXML file generated by AnaSys v2019 rel. 0.0.0.0  -->
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 autosar_4-2-1.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE >
      <SHORT-NAME>RootP_Implementation</SHORT-NAME>
      <ELEMENTS />
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
